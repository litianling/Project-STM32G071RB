# Keil uVision project Project.uvprojx, settings and files
target STM32G071RB-Nucleo_DAC_GenerateWaveform_TriggerHW (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20008FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G071xx
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Doc
    ../: readme.txt
  group Drivers/STM32G0xx_LL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Example/User
    ../Src/: stm32g0xx_it.c main.c
  group Example/MDK-ARM
    ./: startup_stm32g071xx.s
software components: CMSIS:CORE 4.3.0
