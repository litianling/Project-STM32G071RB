# Keil uVision project GPIO_HUIBIANinterrupt_SUCCESS.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GPIO_HUIBIANinterrupt_SUCCESS
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Source Group 1
    ./: startup_stm32g071xx.s
